# Keil uVision project project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ..\..\..\Source\third_party\CMSIS\Core\Include;..\..\..\Source;..\..\project;.\Hardware
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: .\mspm0g3519.sct
  group Source
    ../../../Source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../../../Source/ti/driverlib/m0p/: dl_interrupt.c dl_factoryregion.c
    ../../../Source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0gx51x.c
  group User
    ./: main.c
    ../: empty.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
  group Startup
    ./: startup_mspm0g351x_uvision.s
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Data.c OLED_Data.h Motor.c Motor.h JY901.h JY901.c Encoder.c Encoder.h Grayscale.c Grayscale.h Bluetooth.c Bluetooth.h board.c board.h Track.c Track.h UART.c UART.h PID.c PID.h SpeedPID.c SpeedPID.h YawPID.c YawPID.h GrayscalePID.c GrayscalePID.h Cascade.c Cascade.h
